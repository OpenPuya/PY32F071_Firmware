# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F071xB Puya PY32F071xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: PY32F071xB; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32F071xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F071\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32F071_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f071xB_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/PY32F071xx_Start_Kit/: py32f071xx_ll_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f071.c
  group Drivers/PY32F071_HAL_Driver
    ../../../../../../Drivers/PY32F071_HAL_Driver/Src/: py32f071_ll_utils.c py32f071_ll_i2c.c py32f071_ll_rcc.c py32f071_ll_gpio.c py32f071_ll_dma.c
  group Example/EWARM
    ./: startup_py32f071xx.s
  group Example/User
    ../Src/: main.c py32f071_it.c
