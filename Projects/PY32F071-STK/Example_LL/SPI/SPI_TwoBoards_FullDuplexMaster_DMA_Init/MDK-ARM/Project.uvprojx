# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F071xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.6
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F071xB,USE_FULL_LL_DRIVER
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\PY32F071_HAL_Driver\Inc;..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F071\Include;..\..\..\..\..\..\Drivers\BSP\PY32F071xx_Start_Kit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ../Src/: system_py32f071.c
    ./: startup_py32f071xx.s
  group Application/User
    ../Src/: main.c py32f071_it.c
  group BSP/py32f071xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F071xx_Start_Kit/: py32f071xx_ll_Start_Kit.c
  group Drivers/PY32F071_HAL_Driver
    ../../../../../../Drivers/PY32F071_HAL_Driver/Src/: py32f071_ll_utils.c py32f071_ll_spi.c py32f071_ll_gpio.c py32f071_ll_rcc.c py32f071_ll_dma.c
  group Doc
    ../: readme.txt
