# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F071xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.6
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,PY32F071xB
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\PY32F071xx_Start_Kit;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F071\Include;..\..\..\..\..\..\Drivers\PY32F071_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ../Src/: system_py32f071.c
    ./: startup_py32f071xx.s
  group Application/User
    ../Src/: main.c py32f071_hal_msp.c py32f071_hal_timebase_tim.c py32f071_it.c
  group BSP/py32f071xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F071xx_Start_Kit/: py32f071xx_Start_Kit.c
  group Drivers/PY32F071_HAL_Driver
    ../../../../../../Drivers/PY32F071_HAL_Driver/Src/: py32f071_hal.c py32f071_hal_rcc.c py32f071_hal_rcc_ex.c py32f071_hal_gpio.c py32f071_hal_pwr.c py32f071_hal_usart.c py32f071_hal_tim.c py32f071_hal_tim_ex.c py32f071_hal_uart.c py32f071_hal_dma.c py32f071_hal_cortex.c py32f071_hal_exti.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.1.0
