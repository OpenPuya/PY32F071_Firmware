# IAR project Project.ewp, settings and files
configuration PY32F071xB_Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F071xB Puya PY32F071xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F071xB
  ICCARM.CCIncludePath2: ..\..\..\Drivers\CMSIS\Device\PY32F071\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32F071_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f071xB_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PY32F071x9_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F071x9 Puya PY32F071x9
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F071x9
  ILINK.IlinkIcfFile: py32f071x9_flash.icf
configuration PY32F071x8_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F071x8 Puya PY32F071x8
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F071x8
  ILINK.IlinkIcfFile: py32f071x8_flash.icf
configuration PY32F071x6_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F071x6 Puya PY32F071x6
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F071x6
  ILINK.IlinkIcfFile: py32f071x6_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_py32f071.c
  group Drivers/PY32F071_HAL_Driver
    ../../../Drivers/PY32F071_HAL_Driver/Src/: py32f071_hal.c py32f071_hal_cortex.c py32f071_hal_dma.c py32f071_hal_gpio.c py32f071_hal_pwr.c py32f071_hal_rcc.c py32f071_hal_rcc_ex.c
  group Example/EWARM
    ./: startup_py32f071xx.s
  group Example/User
    ../Src/: main.c py32f071_hal_msp.c py32f071_it.c
